# Keil uVision project Template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c include: ..\SRC\DEVICES;..\SRC\DRIVERS;..\SRC\STARTUP\CoreSupport;..\SRC\STARTUP\DeviceSupport;..\SRC\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group STARTUP
    ../SRC/STARTUP/DeviceSupport/: system_MKL25Z4.c startup_MKL25Z4.s
  group USER
    ../SRC/USER/: main.c
  group DRIVERS
    ../SRC/DRIVERS/: pit.c sys.c adc.c uart.c gpio.c delay.c
  group DEVICES
    ../SRC/DEVICES/: isr.c led.c pid.c cntl.c ccd.c pwm.c
